SRC_URI += "file://user_2021-11-27-21-31-00.cfg \
            file://user_2021-11-27-23-35-00.cfg \
            file://user_2021-11-28-20-17-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

